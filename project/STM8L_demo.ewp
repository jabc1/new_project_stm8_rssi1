# IAR project STM8L_demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\app; ..\user; ..\Sys; ..\function; ..\a7106; ..\DigitalTube
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8L_demo.bin
  ILINK.IlinkOutputFile: STM8L_demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group a7106
    ../a7106/: a7106.c a7106.h a7106gpio.c a7106gpio.h a7106reg.c a7106reg.h
  group APP
    ../app/: main.c stm8l15x_it.c stm8l15x_it.h
  group DigitalTube
    ../DigitalTube/: DigitalTube.c DigitalTube.h LCD.c LCD.h
  group function
    ../function/: function.c function.h table.c table.h
  group Lib
    ../lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group project_cfg
    ../app/: stm8l15x_conf.h
  group ReadME
    ../readme/: ReadMe.txt
  group Sys
    ../Sys/: iwdg.c iwdg.h
  group User
    ../user/: base.h fifo.c fifo.h gpio.c gpio.h lowpower.c lowpower.h queue_jk.c queue_jk.h rtc.c rtc.h time.c time.h uart.c uart.h
